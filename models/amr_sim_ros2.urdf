Commit message: It works

File: models/amr_sim_ros2.urdf (robot description, URDF)
Before this commit: robot amr_bot, 6 links, 5 joints
Joints:
- joint joint_0: origin (none) -> xyz=0 0 0 rpy=0 0 3.14
